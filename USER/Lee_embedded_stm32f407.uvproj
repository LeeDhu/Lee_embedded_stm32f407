# Keil uVision project Lee_embedded_stm32f407.uvproj, settings and files
target Lee_embedded_stm32f407 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lee_embedded_stm32f407 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\USER;..\FWlib\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/StartUp/: startup_stm32f40xx.s
  group USER
    ./: main.c stm32f4xx_it.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group FWlib
    ../FWlib/src/: stm32f4xx_rcc.c
